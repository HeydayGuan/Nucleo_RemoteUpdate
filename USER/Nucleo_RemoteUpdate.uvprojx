# Keil uVision project Nucleo_RemoteUpdate.uvprojx, settings and files
target mbed NUCLEO_F411RE (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Nucleo_RemoteUpdate
  AfterMake: fromelf --bin -o build\Nucleo_RemoteUpdate_NUCLEO_F411RE.bin build\Nucleo_RemoteUpdate.axf
  c flags: Optim=1
  c define: TARGET_FF_ARDUINO,  TARGET_NUCLEO_F411RE,  TARGET_FF_MORPHO,  __FPU_PRESENT=1,  TARGET_CORTEX_M,  TOOLCHAIN_ARM_MICRO,  __MBED__=1,  MBED_BUILD_TIMESTAMP=1446083647.67,  TARGET_M4,  TARGET_STM,  TARGET_STM32F4,  __CORTEX_M4,  TARGET_STM32F411RE,  TOOLCHAIN_ARM,  ARM_MATH_CM4,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;..\;..\mbed\api;..\mbed\common;..\mbed\hal;..\mbed\targets\cmsis;..\mbed\targets\cmsis\TARGET_STM\TARGET_STM32F4;..\mbed\targets\cmsis\TARGET_STM\TARGET_STM32F4\TARGET_NUCLEO_F411RE;..\mbed\targets\hal\TARGET_STM\TARGET_STM32F4;..\mbed\targets\hal\TARGET_STM\TARGET_STM32F4\TARGET_NUCLEO_F411RE;..\rtos\rtos;..\rtos\rtx\TARGET_CORTEX_M;..\lwip;..\lwip\lwip;..\lwip\lwip\include;..\lwip\lwip\include\ipv4;..\lwip\lwip\netif\ppp;..\lwip\lwip-sys;..\lwip\Socket;..\USBHost;..\USBHost3GModule;..\CellularModem;..\CellularModem\at;..\CellularModem\core;..\CellularUSBModem\ip;..\CellularUSBModem;..\CellularUSBModem\serial\usb;..\HuaweiUSBModule;..\http;..\http\data;..\cantcoap;..\MbedJSONValue
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\mbed\targets\cmsis\TARGET_STM\TARGET_STM32F4\TARGET_NUCLEO_F411RE\TOOLCHAIN_ARM_MICRO\stm32f411re.sct
  group USER
    ./: main.cpp
  group common
    ../mbed/common/: assert.c board.c error.c gpio.c lp_ticker_api.c mbed_interface.c pinmap_common.c rtc_time.c semihost_api.c ticker_api.c us_ticker_api.c wait_api.c BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp retarget.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
  group targets\cmsis
    ../mbed/targets/cmsis/TARGET_STM/TARGET_STM32F4/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
    ../mbed/targets/cmsis/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F411RE/: cmsis_nvic.c hal_tick.c system_stm32f4xx.c
  group targets\hal
    ../mbed/targets/hal/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F411RE/: device.h PeripheralPins.c
    ../mbed/targets/hal/TARGET_STM/TARGET_STM32F4/: analogin_api.c analogout_api.c gpio_api.c gpio_irq_api.c i2c_api.c mbed_overrides.c pinmap.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
  group core
    ../mbed/targets/cmsis/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F411RE/TOOLCHAIN_ARM_MICRO/: startup_stm32f411xe.S sys.cpp
  group rtos\rtos
    ../rtos/rtos/: Mutex.cpp RtosTimer.cpp Semaphore.cpp Thread.cpp
  group rtos\rtx
    ../rtos/rtx/TARGET_CORTEX_M/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c RTX_Conf_CM.c
    ../rtos/rtx/TARGET_CORTEX_M/TARGET_M4/TOOLCHAIN_ARM/: HAL_CM4.c SVC_Table.S
  group lwip
    ../lwip/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip/lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../lwip/lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip/lwip/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../lwip/lwip/netif/: etharp.c ethernetif.c slipif.c
    ../lwip/lwip/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group lwip-sys
    ../lwip/lwip-sys/arch/: checksum.c memcpy.c sys_arch.c
  group USBHost
    ../USBHost/: USBDeviceConnected.cpp USBHALHost_F401RE.cpp USBHALHost_KL46Z.cpp USBHALHost_LPC4088.cpp USBHALHost2_F401RE.cpp USBHALHost2_LPC4088.cpp USBHost.cpp USBHostHub.cpp
  group USBHost3GModule
    ../USBHost3GModule/: WANDongle.cpp WANDongleSerialPort.cpp
  group CellularUSBModem
    ../CellularUSBModem/serial/usb/: USBSerialStream.cpp
  group HuaweiUSBModule
    ../HuaweiUSBModule/: HuaweiUSBCDMAModem.cpp HuaweiCDMAModemInitializer.cpp
  group http
    ../http/data/: HTTPMap.cpp HTTPText.cpp
    ../http/: HTTPClient.cpp httptest.cpp
  group CellularModem
    ../CellularModem/core/: dbg.cpp
    ../CellularModem/ip/: IPInterface.cpp LwIPInterface.cpp PPPIPInterface.cpp
    ../CellularModem/at/: ATCommandsInterface.cpp
  group Socket
    ../lwip/Socket/: Endpoint.cpp Socket.cpp TCPSocketConnection.cpp TCPSocketServer.cpp UDPSocket.cpp
  group cantcoap
    ../cantcoap/: cantcoap.cpp
  group MbedJSONValue
    ../MbedJSONValue/: MbedJSONValue.cpp
